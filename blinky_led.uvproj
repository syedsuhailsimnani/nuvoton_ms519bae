# Keil uVision project blinky_led.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: blinky_led +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Nuvoton_BSP\MS51BSP_KEIL-master\MS51FB9AE_MS51XB9AE_MS51XB9BE\Library\Device\Include;..\..\Nuvoton_BSP\MS51BSP_KEIL-master\MS51FB9AE_MS51XB9AE_MS51XB9BE\Library\StdDriver\inc;..\..\Nuvoton_BSP\MS51BSP_KEIL-master\MS51FB9AE_MS51XB9AE_MS51XB9BE\Library\StdDriver\src
  group Source Group 1
    ./: STARTUP.A51 main.c
